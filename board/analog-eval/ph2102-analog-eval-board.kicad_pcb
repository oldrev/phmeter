# Repository oldrev/phmeter

File README.md:

# A pH Meter Analog Front End Board (Experimental)

## KiCad design board/analog-eval/ph2102-analog-eval-board.kicad_pcb

Parts:
C1, C2, C5, C10, C11, C13, C14, C15: 1u; C_0603_1608Metric
C3, C4, C9, C12, C20, C21: 100n; C_0603_1608Metric
C6: 10n; C_0603_1608Metric
C7: 1n; C_0603_1608Metric
C8, C17: 10u; C_0603_1608Metric
C16: 4u7; C_0603_1608Metric
C18, C19: 2u2; C_0603_1608Metric
C22: 100u; CP_EIA-3528-15_AVX-H
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3_Pad_Via
J1: CONN_PROBE; BNC_Amphenol_B6252HB-NPP3G-50_Horizontal
J2: CONN_OUT; PinHeader_1x10_P2.54mm_Vertical
J3: CONN_NTC; JST_XH_S2B-XH-A-1_1x02_P2.50mm_Horizontal
NT1: NetTie_2; NetTie-2_SMD_Pad2.0mm
R1, R2, R3, R4, R5, R6, R9, R19: 10k/0.1%; R_0603_1608Metric
R7, R21, R22: 100R; R_0603_1608Metric
R8: 1M/1%; R_0603_1608Metric
R10: 9.1k/0.1%; R_0603_1608Metric
R11, R12, R13, R23: 10k; R_0603_1608Metric
R14, R15: 76.8k; R_0603_1608Metric
R16, R17: 73.2k; R_0603_1608Metric
R18: 0R0; R_1206_3216Metric_Pad1.30x1.75mm_HandSolder
TP1: TP_PGOOD; TestPoint_Pad_D1.0mm
TP2: TP_GUARD
TP3: TP_2V5; PinHeader_1x02_P2.54mm_Vertical
U1: LMC662; SOIC-8_3.9x4.9mm_P1.27mm
U2: TLV2333; SOIC-8_3.9x4.9mm_P1.27mm
U3: REF3020; SOT-23
U4: MCP3201-BI/SN; SOIC-8_3.9x4.9mm_P1.27mm
U5: LM27762; WSON-12-1EP_3x2mm_P0.5mm_EP1x2.65_ThermalVias

Connections:
+2V5: C1.2, C4.2, C5.2, C10.2, C18.1, R14.1, TP3.1, U1.8 (V+), U2.8 (V+), U3.1 (IN), U5.11 (OUT+)
+3V3: C9.1, C13.1, C14.2, C17.2, C22.1, J2.1, R11.2, U4.8 (Vdd), U5.3 (VIN), U5.8 (EN-), U5.12 (EN+)
-2V5: C2.2, C11.2, C19.2, R15.2, TP3.2, U1.4 (V-), U2.4 (V-), U5.6 (OUT-)
/ADC_CS: J2.3, R11.1, U4.5 (~CS/SHDN)
/ADC_MISO: J2.4, U4.6 (Dout)
/ADC_SCK: J2.5, U4.7 (CLK)
/GUARD: R7.1, TP2.1
/NTC_IN: J3.1, R19.1, R23.1
/NTC_OUT: C20.1, J2.9, R21.2
/PH+: J1.1 (In), R8.1
/VPH: C7.2, J2.8, R22.2, U4.2 (IN+)
GND: J2.2, NT1.2
GNDA: C1.1, C2.1, C3.2, C4.1, C5.1, C7.1, C8.2, C9.2, C10.1, C11.1, C12.2, C13.2, C14.1, C16.2, C17.1, C18.2, C19.1, C20.2, C21.2, C22.2, H1.1, H2.1, H3.1, H4.1, J1.2 (Ext), J2.6, J2.10, J3.2, NT1.1, R4.2, R9.2, R12.1, R16.2, R17.2, U3.3 (GND), U4.3 (IN-), U4.4 (Vss), U5.4 (GND), U5.13 (PAD)
unnamed: C3.1, R3.2, R4.1, U2.3 (+)
unnamed: C6.1, R5.2, R6.1, U2.2 (-)
unnamed: C6.2, R6.2, R12.2, R22.1, U2.1
unnamed: C15.1, U5.9 (C-)
unnamed: C15.2, U5.10 (C+)
unnamed: C16.1, U5.5 (CP)
unnamed: C21.1, R23.2, U2.5 (+)
unnamed: R1.2, R2.1
unnamed: R2.2, R3.1
unnamed: R7.2, U1.1, U1.2 (-)
unnamed: R8.2, U1.5 (+)
unnamed: R9.1, R10.1, R18.1, U1.3 (+)
unnamed: R5.1, R10.2, U1.7
unnamed: R13.1, TP1.1
unnamed: R13.2, U5.1 (PGOOD)
unnamed: R14.2, R16.1, U5.2 (FB+)
unnamed: R15.1, R17.1, U5.7 (FB-)
unnamed: R18.2, U1.6 (-)
unnamed: R21.1, U2.6 (-), U2.7
VREF: C8.1, C12.1, J2.7, R1.1, R19.2, U3.2 (OUT), U4.1 (Vref)

Notes on the sheet:
VOUT = 1.2V × (R1 + R2) / R2
GUARD
GUARD_DRIVER
0.512V
12位ADC
参考电压 2.048V

Board: 2 copper layers, 43.2 x 63.5 mm, 76 parts (1 on the bottom side), 32 nets.

Other parts of the board:
kibuzzard-61663E8D: G***; kibuzzard-61663E8D
kibuzzard-61663E77: G***; kibuzzard-61663E77
kibuzzard-61670BF9: G***; kibuzzard-61670BF9
kibuzzard-616637D2: G***; kibuzzard-616637D2
kibuzzard-616637F4: G***; kibuzzard-616637F4
kibuzzard-6166377A: G***; kibuzzard-6166377A
kibuzzard-6166380D, kibuzzard-6166380D#2: G***; kibuzzard-6166380D
kibuzzard-6166382A: G***; kibuzzard-6166382A
kibuzzard-6166390D: G***; kibuzzard-6166390D
kibuzzard-61663736: G***; kibuzzard-61663736
kibuzzard-61663788: G***; kibuzzard-61663788
kibuzzard-61663800: G***; kibuzzard-61663800
kibuzzard-61663837: G***; kibuzzard-61663837
kibuzzard-61663842: G***; kibuzzard-61663842
kibuzzard-61663968: G***; kibuzzard-61663968
kibuzzard-61663979: G***; kibuzzard-61663979

## Commit log

2021-02-20 init
2021-02-20 完善仿真
2021-02-20 板子修改
2021-02-22 去掉自动保存的文件
2021-02-22 删除自动保存的文件
2021-02-22 添加 LM27762 的模型
2021-02-22 改进 layout
2021-02-23 完善 layout
2021-02-23 ready to fabricate
2021-10-16 add firmware
2021-10-16 add image
2021-10-16 各种完善
